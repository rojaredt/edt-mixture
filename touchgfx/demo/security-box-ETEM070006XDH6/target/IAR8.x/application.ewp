# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\gui\include; ..\..\target\include; ..\..\platform\os; ..\..\generated\fonts\include; ..\..\generated\images\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\Components; ..\bsp\source\vendor\ETEM070006XDH6; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m7\IAR8.x\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp Font_FiraMono_Medium_24_4bpp.cpp Font_KohinoorBangla_24_4bpp.cpp Font_KohinoorBangla_26_4bpp.cpp Font_KohinoorBangla_32_4bpp.cpp Font_Roboto_Medium_40_4bpp.cpp Font_Roboto_Medium_48_4bpp.cpp Font_RobotoCondensed_Regular_26_4bpp.cpp FontGetters.cpp Kerning_FiraMono_Medium_24_4bpp.cpp Kerning_KohinoorBangla_24_4bpp.cpp Kerning_KohinoorBangla_26_4bpp.cpp Kerning_KohinoorBangla_32_4bpp.cpp Kerning_Roboto_Medium_40_4bpp.cpp Kerning_Roboto_Medium_48_4bpp.cpp Kerning_RobotoCondensed_Regular_26_4bpp.cpp Table_FiraMono_Medium_24_4bpp.cpp Table_KohinoorBangla_24_4bpp.cpp Table_KohinoorBangla_26_4bpp.cpp Table_KohinoorBangla_32_4bpp.cpp Table_Roboto_Medium_40_4bpp.cpp Table_Roboto_Medium_48_4bpp.cpp Table_RobotoCondensed_Regular_26_4bpp.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/info_screen
    ../../generated/gui_generated/src/info_screen/: InfoViewBase.cpp
  group Application/generated/gui_generated/log_screen
    ../../generated/gui_generated/src/log_screen/: LogViewBase.cpp
  group Application/generated/gui_generated/main_screen
    ../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/generated/gui_generated/settings_screen
    ../../generated/gui_generated/src/settings_screen/: SettingsViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: BitmapDatabase.cpp clear_unlock_log_press.cpp clear_unlock_log_release.cpp config_background.cpp english_keyboard_background.cpp info_background.cpp info_press.cpp info_release.cpp keyboard_key_delete_press.cpp keyboard_key_enter_press.cpp keyboard_key_highlight_english.cpp keyboard_mask.cpp keyboard_mask_correct.cpp keyboard_mask_error.cpp lock_off.cpp lock_on.cpp log_background.cpp log_list_background.cpp log_press.cpp log_rlease.cpp log_title.cpp log_title_background.cpp logo_edt.cpp logo_smart_embedded.cpp main_background.cpp numberpad_background.cpp numberpad_key_delete_press.cpp numberpad_key_enter_press.cpp numberpad_key_press.cpp return_press.cpp return_release.cpp setting_release.cpp settings_press.cpp wifi_off.cpp wifi_on.cpp wifi_on_0.cpp wifi_on_1.cpp wifi_on_2.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: CustomKeyboard.cpp FrontendApplication.cpp Mask.cpp
  group Application/gui/info_screen
    ../../gui/src/info_screen/: InfoPresenter.cpp InfoView.cpp
  group Application/gui/log_screen
    ../../gui/src/log_screen/: LogPresenter.cpp LogView.cpp
  group Application/gui/main_screen
    ../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/settings_screen
    ../../gui/src/settings_screen/: SettingsPresenter.cpp SettingsView.cpp
  group Application/main
    ../: main.cpp
  group Board/ETEM070006XDH6
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/ETEM070006XDH6/BSP
    ../bsp/source/bsp/: ETEM070006XDH6TouchController.cpp STM32F7Instrumentation.cpp
  group Board/ETEM070006XDH6/Vendor
    ../bsp/source/vendor/ETEM070006XDH6/: etem070006xdh6.c etem070006xdh6_lcd.c etem070006xdh6_qspi.c etem070006xdh6_sdram.c etem070006xdh6_ts.c
    ../bsp/source/vendor/Components/hy4614/: hy4614.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
